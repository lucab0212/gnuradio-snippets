options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: param
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 44.1e3
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ~/gnuradio-snippets/param_file_picker/CURRENT_FILE
    repeat: 'True'
  states: {}
- name: file
  id: parameter
  parameters:
    label: File name
    type: str
    value: silence.wav
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os, shutil
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      file = self.file
      repo_name = 'gnuradio-snippets/'

      cwd = os.getcwd()
      repo_dir = cwd.split(repo_name, 1)[0] + repo_name
      replace_src = repo_dir + 'sample_files/' + file

      if not os.path.isfile(replace_src):
      	print('Error: Chosen file ' + replace_src + ' could not be found.')
      	exit(1)

      replace_dst = cwd + '/CURRENT_FILE'

      shutil.copy(replace_src, replace_dst)
    section: main_after_init
  states: {}

connections:
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
